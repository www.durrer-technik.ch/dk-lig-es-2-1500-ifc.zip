Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 0fa2ad05-935d-4ff3-a2ef-f96a226f50da, NumberOfSaves: 1]
File name: DK-LIG-ES-2-1500.ifc
Time: 2025-10-06T10:52:28+01:00
Written by: ODA SDAI 24.11
Made in: Autodesk Revit 25.0.2.419 (DEU) - IFC 25.0.2.419

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m
Andere - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Familie1:Norm, Familie1:Norm:2424441
In: Default
Type - Material: RGB 165-173-177, <Unnamed>
Type - Andere - Kategorie: Allgemeines Modell; Familienname: Familie1
Type - Modelleigenschaften - Autor: M36842; Bauteilnummer: DK-LIG-ES-2-1500; Erstellungsdatum: 07.10.2024; Firma: Krantz GmbH; Konstrukteur: M36842; Konstruktionsstatus: 1; Titel: Titel
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - Bemaßungen - Verbindung_1_Durchmesser: 0.125 m
Type - ID-Daten - Typname: Norm
Pset_BuildingElementProxyCommon - Reference: Norm; sets with these values: 2
Andere - Familie: Familie1; Familie und Typ: Familie1: Norm; Typ: Norm; Typ-ID: 2424426
Abhängigkeiten - Basisbauteil: Keine; Höhe von Ebene: 0 m; Versatz von Host: 0 m
Bemaßungen - Fläche: 0.900908 m2; Volumen: 0.084527 m3
Phasen - Phase erstellt: Phase 2

# IfcDistributionPort, InPort_2424441_1
Description: Flow; FlowDirection: SINK
